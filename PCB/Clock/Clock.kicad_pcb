File: PCB/Clock/Clock.kicad_pcb (KiCad board)
At the start: 2 copper layers, 120 x 120 mm, 410 parts

Commit message: Library update
Parts:
- removed REF**: Shadow, RevK:Shadow
